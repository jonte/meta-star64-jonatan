FILESEXTRAPATHS:prepend := "${THISDIR}/files/:"

SRC_URI += " \
	file://0001-rtl8852bu-Reset-8852bu-on-module-initialization-on-s.patch \
"
